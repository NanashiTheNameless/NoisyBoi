File: NoisyBoi.kicad_sch (KiCad schematic)
At the start: 20 parts, among them U1 OPA2134UA

Commit message: update
Connections:
- net +4.5V renamed V-+
- net -4.5V renamed V--
